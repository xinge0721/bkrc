# Keil uVision project CarV2.0.uvprojx, settings and files
target CarV2.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CarV2.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CMSIS;..\FWLIB\inc;..\USER;..\HARDWARE\Task_Board;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\Core_Board;..\HARDWARE\CAN;..\my_lib;..\SYSTEM\timer;..\HARDWARE\Full;..\SYSTEM\delay;..\HARDWARE;..\HARDWARE\AGV;..\HARDWARE\DAOZA;..\HARDWARE\garage;..\HARDWARE\LED;..\HARDWARE\TFT;..\HARDWARE\WIRELESSCHARGING;..\HARDWARE\TRAFFIC_LIGHT;..\HARDWARE\VOICEBROADCAST;..\HARDWARE\Intelligent_street_lamp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/Task_Board/: infrared.c tba.c ultrasonic.c bh1750.c tba.h ultrasonic.h bh1750.h infrared.h
    ../HARDWARE/Core_Board/: cba.c usart.c power_check.c uart_a72.c uart_drv.c RC522.C cba.h usart.h power_check.h uart_a72.h uart_drv.h RC522.H
    ../HARDWARE/: Infrared_marker.c mytest.c Rotate.c baojing.c Infrared_marker.h mytest.h Rotate.h baojing.h
    ../HARDWARE/AGV/: AGV.c AGV.h
    ../HARDWARE/DAOZA/: daoza.c daoza.h
    ../HARDWARE/garage/: garage.c garage.h
    ../HARDWARE/LED/: LED.c LED.h
    ../HARDWARE/TFT/: TFT.c TFT.h
    ../HARDWARE/WIRELESSCHARGING/: wirelesscharging.c wirelesscharging.h
    ../HARDWARE/TRAFFIC_LIGHT/: trafficlight.c trafficlight.h
    ../HARDWARE/VOICEBROADCAST/: voicebroadcast.c voicebroadcast.h
    ../HARDWARE/Intelligent_street_lamp/: Intelligent_street_lamp.c Intelligent_street_lamp.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/timer/: Timer.c Timer.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../FWLIB/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group my_lib
    ../my_lib/: my_lib.c data_base.c roadway_check.c data_filtering.c my_lib.h roadway_check.h data_base.h data_filtering.h
  group CAN
    ../HARDWARE/CAN/: can_drv.c CanP_HostCom.c fifo_drv.c Hard_Can.c can_user.c Can_check.c can_drv.h canp_hostcom.h fifo_drv.h Hard_Can.h can_user.h Can_check.h
